# Keil uVision project H7B0_Test.uvprojx, settings and files
target H7B0_Test (6180000::V6.18::ARMCLANG)
  device: STM32H7B0VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00100000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00020000) XRAM2(0x38000000,0x00008000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: H7B0_Test +hex
  c flags: Optim=4 uC99=1 uGnu=1 v6Lang=6 v6LangP=7 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7B0xx,CMB_CODE_SECTION_NAME=ER_ROM1,USE_FULL_LL_DRIVER
  c include: Core\Inc;Drivers\STM32H7xx_HAL_Driver\Inc;Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;Drivers\CMSIS\Device\ST\STM32H7xx\Include;Drivers\CMSIS\Include;.cmsis\include;MDK-ARM\RTE\_H7B0_Test;.eide\deps;Core\Src;Drivers\STM32H7xx_HAL_Driver\Src;MDK-ARM;..\EmbeddedModules;..\EmbeddedModules\utility;..\EmbeddedModules\utility\xv;..\EmbeddedModules\utility\term_table;..\EmbeddedModules\utility\ryu;..\EmbeddedModules\utility\perf_counter;..\EmbeddedModules\utility\lwprintf;..\EmbeddedModules\utility\incbin;..\EmbeddedModules\utility\embedded_cli;..\EmbeddedModules\utility\embedded_cli\utils;..\EmbeddedModules\utility\cot_menu;..\EmbeddedModules\system\s_task\src;..\EmbeddedModules\system\s_task\include;..\EmbeddedModules\system\scheduler_lite;..\EmbeddedModules\system\scheduler;..\EmbeddedModules\system\lwmem;..\EmbeddedModules\system\klite\port\cortex-m4_7;..\EmbeddedModules\system\klite\opt;..\EmbeddedModules\system\klite\kernel;..\EmbeddedModules\system\heap_4;..\EmbeddedModules\system\dalloc;..\EmbeddedModules\storage\littlefs;..\EmbeddedModules\peripheral\ws2812_spi;..\EmbeddedModules\peripheral\uart_pack;..\EmbeddedModules\peripheral\sw_spi;..\EmbeddedModules\peripheral\sw_i2c;..\EmbeddedModules\peripheral\stepper;..\EmbeddedModules\peripheral\spif;..\EmbeddedModules\peripheral\motor;..\EmbeddedModules\peripheral\ll_i2c;..\EmbeddedModules\peripheral\key;..\EmbeddedModules\peripheral\i2c_slave;..\EmbeddedModules\peripheral\board_led;..\EmbeddedModules\peripheral\board_i2c;..\EmbeddedModules\nn\genann;..\EmbeddedModules\graphics\virtual_lcd;..\EmbeddedModules\graphics\ugui;..\EmbeddedModules\graphics\easy_ui;..\EmbeddedModules\debug\RTT;..\EmbeddedModules\debug\minctest;..\EmbeddedModules\debug\log;..\EmbeddedModules\debug\cm_backtrace;..\EmbeddedModules\debug\cm_backtrace\Languages\zh-CN;..\EmbeddedModules\debug\cm_backtrace\Languages\en-US;..\EmbeddedModules\debug\benchmark\coremark_port;..\EmbeddedModules\debug\benchmark\coremark;..\EmbeddedModules\datastruct\ulist;..\EmbeddedModules\datastruct\udict;..\EmbeddedModules\datastruct\sds;..\EmbeddedModules\datastruct\pqueue;..\EmbeddedModules\datastruct\lwrb;..\EmbeddedModules\datastruct\linux_list;..\EmbeddedModules\datastruct\lfifo;..\EmbeddedModules\datastruct\lfbb;..\EmbeddedModules\datastruct\json;..\EmbeddedModules\datastruct\hashmap;..\EmbeddedModules\datastruct\fifofast;..\EmbeddedModules\datastruct\fifofast\utility\macros\mpl;..\EmbeddedModules\datastruct\fifofast\utility\macros\com;..\EmbeddedModules\datastruct\dlist;..\EmbeddedModules\datastruct\ctl;..\EmbeddedModules\datastruct\ctl\bits;..\EmbeddedModules\datastruct\cstring;..\EmbeddedModules\datastruct\btree;..\EmbeddedModules\communication\xymodem;..\EmbeddedModules\communication\TinyFrame;..\EmbeddedModules\communication\TinyFrame\utilities;..\EmbeddedModules\communication\modbus;..\EmbeddedModules\communication\minmea;..\EmbeddedModules\communication\lwpkt;..\EmbeddedModules\algorithm\tiny_regex;..\EmbeddedModules\algorithm\quaternion;..\EmbeddedModules\algorithm\pid;..\EmbeddedModules\algorithm\libcrc;Board
  asm define: as above
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x20000
  memory RVCT7: RAM 0x38000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x100000
  group CORE/SRC
    Core/Src/: dma.c gpio.c i2c.c main.c spi.c stm32h7xx_hal_msp.c stm32h7xx_it.c system_stm32h7xx.c usart.c
  group DRIVERS/STM32H7XX_HAL_DRIVER/SRC
    Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_dma.c stm32h7xx_ll_exti.c stm32h7xx_ll_gpio.c stm32h7xx_ll_i2c.c stm32h7xx_ll_rcc.c stm32h7xx_ll_utils.c
  group MDK-ARM
    MDK-ARM/: startup_stm32h7b0xx.s
  group ../EMBEDDEDMODULES/UTILITY/XV
    ../EmbeddedModules/utility/xv/: xv.c xv_extend.c
  group ../EMBEDDEDMODULES/UTILITY/TERM_TABLE
    ../EmbeddedModules/utility/term_table/: term_table.c
  group ../EMBEDDEDMODULES/UTILITY/RYU
    ../EmbeddedModules/utility/ryu/: ryu.c
  group ../EMBEDDEDMODULES/UTILITY/PERF_COUNTER
    ../EmbeddedModules/utility/perf_counter/: perf_counter.c systick_wrapper_ual.s
  group ../EMBEDDEDMODULES/UTILITY/LWPRINTF
    ../EmbeddedModules/utility/lwprintf/: lwprintf.c
  group ../EMBEDDEDMODULES/UTILITY/EMBEDDED_CLI
    ../EmbeddedModules/utility/embedded_cli/: embedded_cli.c
  group ../EMBEDDEDMODULES/UTILITY/EMBEDDED_CLI/UTILS
    ../EmbeddedModules/utility/embedded_cli/utils/: fs_utils.c sys_utils.c
  group ../EMBEDDEDMODULES/UTILITY/COT_MENU
    ../EmbeddedModules/utility/cot_menu/: cot_menu.c
  group ../EMBEDDEDMODULES/SYSTEM/S_TASK/SRC
    ../EmbeddedModules/system/s_task/src/: s_chan.c s_chan_embed.c s_event.c s_event_embed.c s_list.c s_mutex.c s_rbtree.c s_task.c s_timer_fast.c s_timer_small.c
  group ../EMBEDDEDMODULES/SYSTEM/SCHEDULER_LITE
    ../EmbeddedModules/system/scheduler_lite/: scheduler_lite.c
  group ../EMBEDDEDMODULES/SYSTEM/SCHEDULER
    ../EmbeddedModules/system/scheduler/: scheduler.c scheduler_calllater.c scheduler_coroutine.c scheduler_debug.c scheduler_event.c scheduler_softint.c scheduler_task.c scheduler_terminal.c
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/SRC
    ../EmbeddedModules/system/rtthread_nano/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/LIBCPU/RISC-V/RV32M1
    ../EmbeddedModules/system/rtthread_nano/libcpu/risc-v/rv32m1/: interrupt.c interrupt_gcc.S
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/LIBCPU/RISC-V/K210
    ../EmbeddedModules/system/rtthread_nano/libcpu/risc-v/k210/: cpuport_smp.c interrupt.c interrupt_gcc.S startup_gcc.S tick.c
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/LIBCPU/RISC-V/E310
    ../EmbeddedModules/system/rtthread_nano/libcpu/risc-v/e310/: context_gcc.S entry_gcc.S stack.c
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/LIBCPU/RISC-V/COMMON
    ../EmbeddedModules/system/rtthread_nano/libcpu/risc-v/common/: context_gcc.S cpuport.c
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/LIBCPU/RISC-V/BUMBLEBEE
    ../EmbeddedModules/system/rtthread_nano/libcpu/risc-v/bumblebee/: interrupt_gcc.S
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/LIBCPU/ARM/CORTEX-R4
    ../EmbeddedModules/system/rtthread_nano/libcpu/arm/cortex-r4/: context_ccs.asm context_gcc.S cpu.c interrupt.c stack.c start_ccs.asm start_gcc.S trap.c vector_ccs.asm vector_gcc.S
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/LIBCPU/ARM/CORTEX-M7
    ../EmbeddedModules/system/rtthread_nano/libcpu/arm/cortex-m7/: context_gcc.S context_iar.S context_rvds.S cpuport.c cpu_cache.c
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/LIBCPU/ARM/CORTEX-M4
    ../EmbeddedModules/system/rtthread_nano/libcpu/arm/cortex-m4/: context_gcc.S context_iar.S context_rvds.S cpuport.c
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/LIBCPU/ARM/CORTEX-M33
    ../EmbeddedModules/system/rtthread_nano/libcpu/arm/cortex-m33/: context_gcc.S context_iar.S context_rvds.S cpuport.c syscall_gcc.S syscall_iar.S syscall_rvds.S trustzone.c
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/LIBCPU/ARM/CORTEX-M3
    ../EmbeddedModules/system/rtthread_nano/libcpu/arm/cortex-m3/: context_gcc.S context_iar.S context_rvds.S cpuport.c
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/LIBCPU/ARM/CORTEX-M23
    ../EmbeddedModules/system/rtthread_nano/libcpu/arm/cortex-m23/: context_gcc.S context_iar.S context_rvds.S cpuport.c
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/LIBCPU/ARM/CORTEX-M0
    ../EmbeddedModules/system/rtthread_nano/libcpu/arm/cortex-m0/: context_gcc.S context_iar.S context_rvds.S cpuport.c
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/LIBCPU/ARM/CORTEX-A
    ../EmbeddedModules/system/rtthread_nano/libcpu/arm/cortex-a/: cache.c context_gcc.S cp15_gcc.S cpu.c gic.c interrupt.c mmu.c pmu.c stack.c start_gcc.S trap.c vector_gcc.S
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/LIBCPU/ARM/COMMON
    ../EmbeddedModules/system/rtthread_nano/libcpu/arm/common/: backtrace.c div0.c divsi3.S showmem.c
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/LIBCPU/ARM/ARMV6
    ../EmbeddedModules/system/rtthread_nano/libcpu/arm/armv6/: arm_entry_gcc.S context_gcc.S cpuport.c mmu.c stack.c vfp.c
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/LIBCPU/ARM/ARM926
    ../EmbeddedModules/system/rtthread_nano/libcpu/arm/arm926/: context_gcc.S context_iar.S context_rvds.S cpuport.c machine.c mmu.c stack.c start_gcc.S start_iar.S start_rvds.S trap.c
  group ../EMBEDDEDMODULES/SYSTEM/RTTHREAD_NANO/BSP
    ../EmbeddedModules/system/rtthread_nano/bsp/: board.c
  group ../EMBEDDEDMODULES/SYSTEM/LWMEM
    ../EmbeddedModules/system/lwmem/: lwmem.c
  group ../EMBEDDEDMODULES/SYSTEM/KLITE/PORT/CORTEX-M4_7
    ../EmbeddedModules/system/klite/port/cortex-m4_7/: cmsis.c cpu.c cpu_asm_gcc.s cpu_asm_iar.s cpu_asm_keil.s
  group ../EMBEDDEDMODULES/SYSTEM/KLITE/PORT/CORTEX-M3
    ../EmbeddedModules/system/klite/port/cortex-m3/: cmsis.c cpu.c cpu_asm_gcc.s cpu_asm_iar.s cpu_asm_keil.s
  group ../EMBEDDEDMODULES/SYSTEM/KLITE/PORT/CORTEX-M0
    ../EmbeddedModules/system/klite/port/cortex-m0/: cmsis.c cpu.c cpu_asm_gcc.s cpu_asm_iar.s cpu_asm_keil.s
  group ../EMBEDDEDMODULES/SYSTEM/KLITE/OPT
    ../EmbeddedModules/system/klite/opt/: event_flags.c fifo.c mailbox.c mpool.c queue.c soft_timer.c thread_pool.c
  group ../EMBEDDEDMODULES/SYSTEM/KLITE/KERNEL
    ../EmbeddedModules/system/klite/kernel/: cond.c event.c heap_bare.c heap_heap4.c heap_lwmem.c hook.c kernel.c mutex.c sched.c sem.c thread.c
  group ../EMBEDDEDMODULES/SYSTEM/HEAP_4
    ../EmbeddedModules/system/heap_4/: heap_4.c
  group ../EMBEDDEDMODULES/SYSTEM/DALLOC
    ../EmbeddedModules/system/dalloc/: dalloc.c
  group ../EMBEDDEDMODULES/STORAGE/MINIFLASHDB
    ../EmbeddedModules/storage/MiniFlashDB/: mf.c
  group ../EMBEDDEDMODULES/STORAGE/LITTLEFS
    ../EmbeddedModules/storage/littlefs/: lfs.c lfs_util.c
  group ../EMBEDDEDMODULES/PERIPHERAL/WS2812_SPI
    ../EmbeddedModules/peripheral/ws2812_spi/: ws2812_spi.c
  group ../EMBEDDEDMODULES/PERIPHERAL/UART_PACK
    ../EmbeddedModules/peripheral/uart_pack/: uart_pack.c uart_pack_cdc.c
  group ../EMBEDDEDMODULES/PERIPHERAL/SW_SPI
    ../EmbeddedModules/peripheral/sw_spi/: sw_spi.c
  group ../EMBEDDEDMODULES/PERIPHERAL/SW_I2C
    ../EmbeddedModules/peripheral/sw_i2c/: sw_i2c.c
  group ../EMBEDDEDMODULES/PERIPHERAL/STEPPER
    ../EmbeddedModules/peripheral/stepper/: stepper.c
  group ../EMBEDDEDMODULES/PERIPHERAL/SPIF
    ../EmbeddedModules/peripheral/spif/: spif.c
  group ../EMBEDDEDMODULES/PERIPHERAL/MOTOR
    ../EmbeddedModules/peripheral/motor/: motor.c
  group ../EMBEDDEDMODULES/PERIPHERAL/LL_I2C
    ../EmbeddedModules/peripheral/ll_i2c/: ll_i2c.c ll_i2c_it.c ll_i2c_poll.c
  group ../EMBEDDEDMODULES/PERIPHERAL/KEY
    ../EmbeddedModules/peripheral/key/: key.c
  group ../EMBEDDEDMODULES/PERIPHERAL/I2C_SLAVE
    ../EmbeddedModules/peripheral/i2c_slave/: i2c_slave.c
  group ../EMBEDDEDMODULES/PERIPHERAL/BOARD_LED
    ../EmbeddedModules/peripheral/board_led/: led.c
  group ../EMBEDDEDMODULES/PERIPHERAL/BOARD_I2C
    ../EmbeddedModules/peripheral/board_i2c/: board_i2c.c
  group ../EMBEDDEDMODULES/NN/GENANN
    ../EmbeddedModules/nn/genann/: genann.c
  group ../EMBEDDEDMODULES/GRAPHICS/VIRTUAL_LCD
    ../EmbeddedModules/graphics/virtual_lcd/: virtual_lcd.c
  group ../EMBEDDEDMODULES/GRAPHICS/UGUI
    ../EmbeddedModules/graphics/ugui/: ugui.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL_GAUSSIAN_BLUR
    ../EmbeddedModules/graphics/lvgl_gaussian_blur/: lvglGaussian.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL-PM
    ../EmbeddedModules/graphics/lvgl-pm/: anima.c pm.c pm_utils.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/WIDGETS
    ../EmbeddedModules/graphics/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/MISC
    ../EmbeddedModules/graphics/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/HAL
    ../EmbeddedModules/graphics/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/FONT
    ../EmbeddedModules/graphics/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA
    ../EmbeddedModules/graphics/lvgl/src/extra/: lv_extra.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/WIDGETS/WIN
    ../EmbeddedModules/graphics/lvgl/src/extra/widgets/win/: lv_win.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/WIDGETS/TILEVIEW
    ../EmbeddedModules/graphics/lvgl/src/extra/widgets/tileview/: lv_tileview.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/WIDGETS/TABVIEW
    ../EmbeddedModules/graphics/lvgl/src/extra/widgets/tabview/: lv_tabview.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/WIDGETS/SPINNER
    ../EmbeddedModules/graphics/lvgl/src/extra/widgets/spinner/: lv_spinner.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/WIDGETS/SPINBOX
    ../EmbeddedModules/graphics/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/WIDGETS/SPAN
    ../EmbeddedModules/graphics/lvgl/src/extra/widgets/span/: lv_span.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/WIDGETS/MSGBOX
    ../EmbeddedModules/graphics/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/WIDGETS/METER
    ../EmbeddedModules/graphics/lvgl/src/extra/widgets/meter/: lv_meter.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/WIDGETS/MENU
    ../EmbeddedModules/graphics/lvgl/src/extra/widgets/menu/: lv_menu.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/WIDGETS/LIST
    ../EmbeddedModules/graphics/lvgl/src/extra/widgets/list/: lv_list.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/WIDGETS/LED
    ../EmbeddedModules/graphics/lvgl/src/extra/widgets/led/: lv_led.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/WIDGETS/KEYBOARD
    ../EmbeddedModules/graphics/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/WIDGETS/IMGBTN
    ../EmbeddedModules/graphics/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/WIDGETS/COLORWHEEL
    ../EmbeddedModules/graphics/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/WIDGETS/CHART
    ../EmbeddedModules/graphics/lvgl/src/extra/widgets/chart/: lv_chart.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/WIDGETS/CALENDAR
    ../EmbeddedModules/graphics/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/WIDGETS/ANIMIMG
    ../EmbeddedModules/graphics/lvgl/src/extra/widgets/animimg/: lv_animimg.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/THEMES/MONO
    ../EmbeddedModules/graphics/lvgl/src/extra/themes/mono/: lv_theme_mono.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/THEMES/DEFAULT
    ../EmbeddedModules/graphics/lvgl/src/extra/themes/default/: lv_theme_default.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/THEMES/BASIC
    ../EmbeddedModules/graphics/lvgl/src/extra/themes/basic/: lv_theme_basic.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/OTHERS/SNAPSHOT
    ../EmbeddedModules/graphics/lvgl/src/extra/others/snapshot/: lv_snapshot.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/OTHERS/MSG
    ../EmbeddedModules/graphics/lvgl/src/extra/others/msg/: lv_msg.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/OTHERS/MONKEY
    ../EmbeddedModules/graphics/lvgl/src/extra/others/monkey/: lv_monkey.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/OTHERS/IMGFONT
    ../EmbeddedModules/graphics/lvgl/src/extra/others/imgfont/: lv_imgfont.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/OTHERS/IME
    ../EmbeddedModules/graphics/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/OTHERS/GRIDNAV
    ../EmbeddedModules/graphics/lvgl/src/extra/others/gridnav/: lv_gridnav.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/OTHERS/FRAGMENT
    ../EmbeddedModules/graphics/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/LIBS/TINY_TTF
    ../EmbeddedModules/graphics/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/LIBS/SJPG
    ../EmbeddedModules/graphics/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/LIBS/RLOTTIE
    ../EmbeddedModules/graphics/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/LIBS/QRCODE
    ../EmbeddedModules/graphics/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/LIBS/PNG
    ../EmbeddedModules/graphics/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/LIBS/GIF
    ../EmbeddedModules/graphics/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/LIBS/FSDRV
    ../EmbeddedModules/graphics/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/LIBS/FREETYPE
    ../EmbeddedModules/graphics/lvgl/src/extra/libs/freetype/: lv_freetype.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/LIBS/FFMPEG
    ../EmbeddedModules/graphics/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/LIBS/BMP
    ../EmbeddedModules/graphics/lvgl/src/extra/libs/bmp/: lv_bmp.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/LAYOUTS/GRID
    ../EmbeddedModules/graphics/lvgl/src/extra/layouts/grid/: lv_grid.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/EXTRA/LAYOUTS/FLEX
    ../EmbeddedModules/graphics/lvgl/src/extra/layouts/flex/: lv_flex.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/DRAW
    ../EmbeddedModules/graphics/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/DRAW/SWM341_DMA2D
    ../EmbeddedModules/graphics/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/DRAW/SW
    ../EmbeddedModules/graphics/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/DRAW/STM32_DMA2D
    ../EmbeddedModules/graphics/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/DRAW/SDL
    ../EmbeddedModules/graphics/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/DRAW/RENESAS
    ../EmbeddedModules/graphics/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/DRAW/NXP/VGLITE
    ../EmbeddedModules/graphics/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/DRAW/NXP/PXP
    ../EmbeddedModules/graphics/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/DRAW/ARM2D
    ../EmbeddedModules/graphics/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/SRC/CORE
    ../EmbeddedModules/graphics/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/PORTING
    ../EmbeddedModules/graphics/lvgl/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/WIN
    ../EmbeddedModules/graphics/lvgl/examples/widgets/win/: lv_example_win_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/TILEVIEW
    ../EmbeddedModules/graphics/lvgl/examples/widgets/tileview/: lv_example_tileview_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/TEXTAREA
    ../EmbeddedModules/graphics/lvgl/examples/widgets/textarea/: lv_example_textarea_1.c lv_example_textarea_2.c lv_example_textarea_3.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/TABVIEW
    ../EmbeddedModules/graphics/lvgl/examples/widgets/tabview/: lv_example_tabview_1.c lv_example_tabview_2.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/TABLE
    ../EmbeddedModules/graphics/lvgl/examples/widgets/table/: lv_example_table_1.c lv_example_table_2.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/SWITCH
    ../EmbeddedModules/graphics/lvgl/examples/widgets/switch/: lv_example_switch_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/SPINNER
    ../EmbeddedModules/graphics/lvgl/examples/widgets/spinner/: lv_example_spinner_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/SPINBOX
    ../EmbeddedModules/graphics/lvgl/examples/widgets/spinbox/: lv_example_spinbox_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/SPAN
    ../EmbeddedModules/graphics/lvgl/examples/widgets/span/: lv_example_span_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/SLIDER
    ../EmbeddedModules/graphics/lvgl/examples/widgets/slider/: lv_example_slider_1.c lv_example_slider_2.c lv_example_slider_3.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/ROLLER
    ../EmbeddedModules/graphics/lvgl/examples/widgets/roller/: lv_example_roller_1.c lv_example_roller_2.c lv_example_roller_3.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/OBJ
    ../EmbeddedModules/graphics/lvgl/examples/widgets/obj/: lv_example_obj_1.c lv_example_obj_2.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/MSGBOX
    ../EmbeddedModules/graphics/lvgl/examples/widgets/msgbox/: lv_example_msgbox_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/METER
    ../EmbeddedModules/graphics/lvgl/examples/widgets/meter/: lv_example_meter_1.c lv_example_meter_2.c lv_example_meter_3.c lv_example_meter_4.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/MENU
    ../EmbeddedModules/graphics/lvgl/examples/widgets/menu/: lv_example_menu_1.c lv_example_menu_2.c lv_example_menu_3.c lv_example_menu_4.c lv_example_menu_5.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/LIST
    ../EmbeddedModules/graphics/lvgl/examples/widgets/list/: lv_example_list_1.c lv_example_list_2.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/LINE
    ../EmbeddedModules/graphics/lvgl/examples/widgets/line/: lv_example_line_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/LED
    ../EmbeddedModules/graphics/lvgl/examples/widgets/led/: lv_example_led_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/LABEL
    ../EmbeddedModules/graphics/lvgl/examples/widgets/label/: lv_example_label_1.c lv_example_label_2.c lv_example_label_3.c lv_example_label_4.c lv_example_label_5.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/KEYBOARD
    ../EmbeddedModules/graphics/lvgl/examples/widgets/keyboard/: lv_example_keyboard_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/IMGBTN
    ../EmbeddedModules/graphics/lvgl/examples/widgets/imgbtn/: lv_example_imgbtn_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/IMG
    ../EmbeddedModules/graphics/lvgl/examples/widgets/img/: lv_example_img_1.c lv_example_img_2.c lv_example_img_3.c lv_example_img_4.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/DROPDOWN
    ../EmbeddedModules/graphics/lvgl/examples/widgets/dropdown/: lv_example_dropdown_1.c lv_example_dropdown_2.c lv_example_dropdown_3.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/COLORWHEEL
    ../EmbeddedModules/graphics/lvgl/examples/widgets/colorwheel/: lv_example_colorwheel_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/CHECKBOX
    ../EmbeddedModules/graphics/lvgl/examples/widgets/checkbox/: lv_example_checkbox_1.c lv_example_checkbox_2.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/CHART
    ../EmbeddedModules/graphics/lvgl/examples/widgets/chart/: lv_example_chart_1.c lv_example_chart_2.c lv_example_chart_3.c lv_example_chart_4.c lv_example_chart_5.c lv_example_chart_6.c lv_example_chart_7.c lv_example_chart_8.c lv_example_chart_9.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/CANVAS
    ../EmbeddedModules/graphics/lvgl/examples/widgets/canvas/: lv_example_canvas_1.c lv_example_canvas_2.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/CALENDAR
    ../EmbeddedModules/graphics/lvgl/examples/widgets/calendar/: lv_example_calendar_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/BTNMATRIX
    ../EmbeddedModules/graphics/lvgl/examples/widgets/btnmatrix/: lv_example_btnmatrix_1.c lv_example_btnmatrix_2.c lv_example_btnmatrix_3.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/BTN
    ../EmbeddedModules/graphics/lvgl/examples/widgets/btn/: lv_example_btn_1.c lv_example_btn_2.c lv_example_btn_3.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/BAR
    ../EmbeddedModules/graphics/lvgl/examples/widgets/bar/: lv_example_bar_1.c lv_example_bar_2.c lv_example_bar_3.c lv_example_bar_4.c lv_example_bar_5.c lv_example_bar_6.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/ARC
    ../EmbeddedModules/graphics/lvgl/examples/widgets/arc/: lv_example_arc_1.c lv_example_arc_2.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/WIDGETS/ANIMIMG
    ../EmbeddedModules/graphics/lvgl/examples/widgets/animimg/: lv_example_animimg_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/STYLES
    ../EmbeddedModules/graphics/lvgl/examples/styles/: lv_example_style_1.c lv_example_style_10.c lv_example_style_11.c lv_example_style_12.c lv_example_style_13.c lv_example_style_14.c lv_example_style_15.c lv_example_style_2.c lv_example_style_3.c lv_example_style_4.c lv_example_style_5.c lv_example_style_6.c lv_example_style_7.c lv_example_style_8.c lv_example_style_9.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/SCROLL
    ../EmbeddedModules/graphics/lvgl/examples/scroll/: lv_example_scroll_1.c lv_example_scroll_2.c lv_example_scroll_3.c lv_example_scroll_4.c lv_example_scroll_5.c lv_example_scroll_6.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/OTHERS/SNAPSHOT
    ../EmbeddedModules/graphics/lvgl/examples/others/snapshot/: lv_example_snapshot_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/OTHERS/MSG
    ../EmbeddedModules/graphics/lvgl/examples/others/msg/: lv_example_msg_1.c lv_example_msg_2.c lv_example_msg_3.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/OTHERS/MONKEY
    ../EmbeddedModules/graphics/lvgl/examples/others/monkey/: lv_example_monkey_1.c lv_example_monkey_2.c lv_example_monkey_3.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/OTHERS/IMGFONT
    ../EmbeddedModules/graphics/lvgl/examples/others/imgfont/: lv_example_imgfont_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/OTHERS/IME
    ../EmbeddedModules/graphics/lvgl/examples/others/ime/: lv_example_ime_pinyin_1.c lv_example_ime_pinyin_2.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/OTHERS/GRIDNAV
    ../EmbeddedModules/graphics/lvgl/examples/others/gridnav/: lv_example_gridnav_1.c lv_example_gridnav_2.c lv_example_gridnav_3.c lv_example_gridnav_4.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/OTHERS/FRAGMENT
    ../EmbeddedModules/graphics/lvgl/examples/others/fragment/: lv_example_fragment_1.c lv_example_fragment_2.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/LIBS/SJPG
    ../EmbeddedModules/graphics/lvgl/examples/libs/sjpg/: lv_example_sjpg_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/LIBS/RLOTTIE
    ../EmbeddedModules/graphics/lvgl/examples/libs/rlottie/: lv_example_rlottie_1.c lv_example_rlottie_2.c lv_example_rlottie_approve.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/LIBS/QRCODE
    ../EmbeddedModules/graphics/lvgl/examples/libs/qrcode/: lv_example_qrcode_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/LIBS/PNG
    ../EmbeddedModules/graphics/lvgl/examples/libs/png/: img_wink_png.c lv_example_png_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/LIBS/GIF
    ../EmbeddedModules/graphics/lvgl/examples/libs/gif/: img_bulb_gif.c lv_example_gif_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/LIBS/FREETYPE
    ../EmbeddedModules/graphics/lvgl/examples/libs/freetype/: lv_example_freetype_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/LIBS/FFMPEG
    ../EmbeddedModules/graphics/lvgl/examples/libs/ffmpeg/: lv_example_ffmpeg_1.c lv_example_ffmpeg_2.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/LIBS/BMP
    ../EmbeddedModules/graphics/lvgl/examples/libs/bmp/: lv_example_bmp_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/LAYOUTS/GRID
    ../EmbeddedModules/graphics/lvgl/examples/layouts/grid/: lv_example_grid_1.c lv_example_grid_2.c lv_example_grid_3.c lv_example_grid_4.c lv_example_grid_5.c lv_example_grid_6.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/LAYOUTS/FLEX
    ../EmbeddedModules/graphics/lvgl/examples/layouts/flex/: lv_example_flex_1.c lv_example_flex_2.c lv_example_flex_3.c lv_example_flex_4.c lv_example_flex_5.c lv_example_flex_6.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/GET_STARTED
    ../EmbeddedModules/graphics/lvgl/examples/get_started/: lv_example_get_started_1.c lv_example_get_started_2.c lv_example_get_started_3.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/EVENT
    ../EmbeddedModules/graphics/lvgl/examples/event/: lv_example_event_1.c lv_example_event_2.c lv_example_event_3.c lv_example_event_4.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/ASSETS
    ../EmbeddedModules/graphics/lvgl/examples/assets/: animimg001.c animimg002.c animimg003.c imgbtn_left.c imgbtn_mid.c imgbtn_right.c img_caret_down.c img_cogwheel_alpha16.c img_cogwheel_argb.c img_cogwheel_chroma_keyed.c img_cogwheel_indexed16.c img_cogwheel_rgb.c img_hand.c img_skew_strip.c img_star.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/ASSETS/EMOJI
    ../EmbeddedModules/graphics/lvgl/examples/assets/emoji/: img_emoji_F617.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/EXAMPLES/ANIM
    ../EmbeddedModules/graphics/lvgl/examples/anim/: lv_example_anim_1.c lv_example_anim_2.c lv_example_anim_3.c lv_example_anim_timeline_1.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/DEMOS/WIDGETS
    ../EmbeddedModules/graphics/lvgl/demos/widgets/: lv_demo_widgets.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/DEMOS/WIDGETS/ASSETS
    ../EmbeddedModules/graphics/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/DEMOS/STRESS
    ../EmbeddedModules/graphics/lvgl/demos/stress/: lv_demo_stress.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/DEMOS/MUSIC
    ../EmbeddedModules/graphics/lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/DEMOS/MUSIC/ASSETS
    ../EmbeddedModules/graphics/lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/DEMOS/KEYPAD_ENCODER
    ../EmbeddedModules/graphics/lvgl/demos/keypad_encoder/: lv_demo_keypad_encoder.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/DEMOS/BENCHMARK
    ../EmbeddedModules/graphics/lvgl/demos/benchmark/: lv_demo_benchmark.c
  group ../EMBEDDEDMODULES/GRAPHICS/LVGL/DEMOS/BENCHMARK/ASSETS
    ../EmbeddedModules/graphics/lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
  group ../EMBEDDEDMODULES/GRAPHICS/HAGL/SRC
    ../EmbeddedModules/graphics/hagl/src/: fontx.c hagl.c hagl_bitmap.c hagl_blit.c hagl_char.c hagl_circle.c hagl_clip.c hagl_color.c hagl_ellipse.c hagl_hline.c hagl_image.c hagl_line.c hagl_pixel.c hagl_polygon.c hagl_rectangle.c hagl_tjpgd.c hagl_triangle.c hagl_vline.c hsl.c rgb565.c rgb888.c
  group ../EMBEDDEDMODULES/GRAPHICS/EASY_UI
    ../EmbeddedModules/graphics/easy_ui/: easyui_demo.c easy_ui.c
  group ../EMBEDDEDMODULES/DEBUG/RTT
    ../EmbeddedModules/debug/RTT/: SEGGER_RTT.c SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_printf.c
  group ../EMBEDDEDMODULES/DEBUG/CM_BACKTRACE
    ../EmbeddedModules/debug/cm_backtrace/: cm_backtrace.c
  group ../EMBEDDEDMODULES/DEBUG/CM_BACKTRACE/FAULT_HANDLER/KEIL
    ../EmbeddedModules/debug/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group ../EMBEDDEDMODULES/DEBUG/CM_BACKTRACE/FAULT_HANDLER/IAR
    ../EmbeddedModules/debug/cm_backtrace/fault_handler/iar/: cmb_fault.S
  group ../EMBEDDEDMODULES/DEBUG/CM_BACKTRACE/FAULT_HANDLER/GCC
    ../EmbeddedModules/debug/cm_backtrace/fault_handler/gcc/: cmb_fault.S
  group ../EMBEDDEDMODULES/DEBUG/BENCHMARK/COREMARK_PORT
    ../EmbeddedModules/debug/benchmark/coremark_port/: core_main.c core_portme.c
  group ../EMBEDDEDMODULES/DEBUG/BENCHMARK/COREMARK
    ../EmbeddedModules/debug/benchmark/coremark/: core_list_join.c core_matrix.c core_state.c core_util.c
  group ../EMBEDDEDMODULES/DATASTRUCT/ULIST
    ../EmbeddedModules/datastruct/ulist/: ulist.c
  group ../EMBEDDEDMODULES/DATASTRUCT/UDICT
    ../EmbeddedModules/datastruct/udict/: udict.c
  group ../EMBEDDEDMODULES/DATASTRUCT/SDS
    ../EmbeddedModules/datastruct/sds/: sds.c
  group ../EMBEDDEDMODULES/DATASTRUCT/PQUEUE
    ../EmbeddedModules/datastruct/pqueue/: pqueue.c
  group ../EMBEDDEDMODULES/DATASTRUCT/LWRB
    ../EmbeddedModules/datastruct/lwrb/: lwrb.c
  group ../EMBEDDEDMODULES/DATASTRUCT/LFIFO
    ../EmbeddedModules/datastruct/lfifo/: lfifo.c
  group ../EMBEDDEDMODULES/DATASTRUCT/LFBB
    ../EmbeddedModules/datastruct/lfbb/: lfbb.c
  group ../EMBEDDEDMODULES/DATASTRUCT/JSON
    ../EmbeddedModules/datastruct/json/: json.c
  group ../EMBEDDEDMODULES/DATASTRUCT/HASHMAP
    ../EmbeddedModules/datastruct/hashmap/: hashmap.c
  group ../EMBEDDEDMODULES/DATASTRUCT/DLIST
    ../EmbeddedModules/datastruct/dlist/: dlist.c dlist_iterator.c dlist_node.c
  group ../EMBEDDEDMODULES/DATASTRUCT/CSTRING
    ../EmbeddedModules/datastruct/cstring/: cstring.c
  group ../EMBEDDEDMODULES/DATASTRUCT/BTREE
    ../EmbeddedModules/datastruct/btree/: btree.c
  group ../EMBEDDEDMODULES/COMMUNICATION/XYMODEM
    ../EmbeddedModules/communication/xymodem/: xmodem.c ymodem.c
  group ../EMBEDDEDMODULES/COMMUNICATION/TINYFRAME
    ../EmbeddedModules/communication/TinyFrame/: TF_Integration.example.c TinyFrame.c
  group ../EMBEDDEDMODULES/COMMUNICATION/TINYFRAME/UTILITIES
    ../EmbeddedModules/communication/TinyFrame/utilities/: payload_builder.c payload_parser.c
  group ../EMBEDDEDMODULES/COMMUNICATION/MODBUS
    ../EmbeddedModules/communication/modbus/: modbus.c
  group ../EMBEDDEDMODULES/COMMUNICATION/MINMEA
    ../EmbeddedModules/communication/minmea/: minmea.c
  group ../EMBEDDEDMODULES/COMMUNICATION/LWPKT
    ../EmbeddedModules/communication/lwpkt/: lwpkt.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/PORT/XHCI
    ../EmbeddedModules/communication/CherryUSB/port/xhci/: usb_hc_xhci.c xhci.c xhci_dbg.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/PORT/TEMPLATE
    ../EmbeddedModules/communication/CherryUSB/port/template/: usb_dc.c usb_hc.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/PORT/PUSB2
    ../EmbeddedModules/communication/CherryUSB/port/pusb2/: usb_dc_pusb2.c usb_hc_pusb2.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/PORT/NUVOTON
    ../EmbeddedModules/communication/CherryUSB/port/nuvoton/: usb_dc_usbfs.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/PORT/MUSB
    ../EmbeddedModules/communication/CherryUSB/port/musb/: usb_dc_musb.c usb_hc_musb.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/PORT/HPM
    ../EmbeddedModules/communication/CherryUSB/port/hpm/: usb_dc_hpm.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/PORT/FSDEV
    ../EmbeddedModules/communication/CherryUSB/port/fsdev/: usb_dc_fsdev.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/PORT/EHCI
    ../EmbeddedModules/communication/CherryUSB/port/ehci/: usb_glue_aic.c usb_glue_bouffalo.c usb_glue_hpm.c usb_glue_intel.c usb_hc_ehci.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/PORT/DWC2
    ../EmbeddedModules/communication/CherryUSB/port/dwc2/: usb_dc_dwc2.c usb_glue_at.c usb_glue_gd.c usb_glue_st.c usb_hc_dwc2.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/PORT/CH32
    ../EmbeddedModules/communication/CherryUSB/port/ch32/: usb_ch58x_dc_usbfs.c usb_dc_usbfs.c usb_dc_usbhs.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/OSAL
    ../EmbeddedModules/communication/CherryUSB/osal/: usb_osal_freertos.c usb_osal_rtems.c usb_osal_rtthread.c usb_osal_yoc.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/DEMO
    ../EmbeddedModules/communication/CherryUSB/demo/: audio_v1_mic_multichan_template.c audio_v1_mic_speaker_multichan_template.c audio_v2_mic_multichan_template.c audio_v2_mic_speaker_multichan_template.c audio_v2_speaker_multichan_template.c cdc_acm_hid_msc_template.c cdc_acm_msc_template.c cdc_acm_multi_template.c cdc_acm_template.c cdc_ecm_template.c cdc_rndis_template.c dfu_st_cubemx_main.c dfu_with_st_tool_template.c hid_custom_inout_template.c hid_keyboard_template.c hid_mouse_template.c midi_template.c msc_ram_template.c msc_storage_template.c mtp_template.c printer_template.c usb_host.c video_static_mjpeg_template.c webusb_template.c winusb1.0_template.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/CORE
    ../EmbeddedModules/communication/CherryUSB/core/: usbd_core.c usbh_core.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/CLASS/WIRELESS
    ../EmbeddedModules/communication/CherryUSB/class/wireless/: usbd_rndis.c usbh_bluetooth.c usbh_rndis.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/CLASS/VIDEO
    ../EmbeddedModules/communication/CherryUSB/class/video/: usbd_video.c usbh_video.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/CLASS/TEMPLATE
    ../EmbeddedModules/communication/CherryUSB/class/template/: usbd_xxx.c usbh_xxx.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/CLASS/MSC
    ../EmbeddedModules/communication/CherryUSB/class/msc/: usbd_msc.c usbh_msc.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/CLASS/HUB
    ../EmbeddedModules/communication/CherryUSB/class/hub/: usbh_hub.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/CLASS/HID
    ../EmbeddedModules/communication/CherryUSB/class/hid/: usbd_hid.c usbh_hid.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/CLASS/DFU
    ../EmbeddedModules/communication/CherryUSB/class/dfu/: usbd_dfu.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/CLASS/CDC
    ../EmbeddedModules/communication/CherryUSB/class/cdc/: usbd_cdc.c usbd_cdc_ecm.c usbh_cdc_acm.c usbh_cdc_ecm.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/CLASS/AUDIO
    ../EmbeddedModules/communication/CherryUSB/class/audio/: usbd_audio.c usbh_audio.c
  group ../EMBEDDEDMODULES/COMMUNICATION/CHERRYUSB/APPLICATION
    ../EmbeddedModules/communication/CherryUSB/application/: cdc_acm_app.c
  group ../EMBEDDEDMODULES/ALGORITHM/TINY_REGEX
    ../EmbeddedModules/algorithm/tiny_regex/: tiny_regex.c
  group ../EMBEDDEDMODULES/ALGORITHM/QUATERNION
    ../EmbeddedModules/algorithm/quaternion/: quaternion.c sensor_processing_lib.c vector_3d.c
  group ../EMBEDDEDMODULES/ALGORITHM/PID
    ../EmbeddedModules/algorithm/pid/: pid.c
  group ../EMBEDDEDMODULES/ALGORITHM/LIBCRC
    ../EmbeddedModules/algorithm/libcrc/: crcLib.c
  group ../EMBEDDEDMODULES/ALGORITHM/CMSIS_DSP/SOURCE/WINDOWFUNCTIONS
    ../EmbeddedModules/algorithm/cmsis_dsp/Source/WindowFunctions/: arm_bartlett_f32.c arm_bartlett_f64.c arm_blackman_harris_92db_f32.c arm_blackman_harris_92db_f64.c arm_hamming_f32.c arm_hamming_f64.c arm_hanning_f32.c arm_hanning_f64.c arm_hft116d_f32.c arm_hft116d_f64.c arm_hft144d_f32.c arm_hft144d_f64.c arm_hft169d_f32.c arm_hft169d_f64.c arm_hft196d_f32.c arm_hft196d_f64.c arm_hft223d_f32.c arm_hft223d_f64.c arm_hft248d_f32.c arm_hft248d_f64.c arm_hft90d_f32.c arm_hft90d_f64.c arm_hft95_f32.c arm_hft95_f64.c arm_nuttall3a_f32.c arm_nuttall3a_f64.c arm_nuttall3b_f32.c arm_nuttall3b_f64.c arm_nuttall3_f32.c arm_nuttall3_f64.c arm_nuttall4a_f32.c arm_nuttall4a_f64.c arm_nuttall4b_f32.c arm_nuttall4b_f64.c arm_nuttall4c_f32.c arm_nuttall4c_f64.c arm_nuttall4_f32.c arm_nuttall4_f64.c arm_welch_f32.c arm_welch_f64.c
  group ../EMBEDDEDMODULES/ALGORITHM/CMSIS_DSP/SOURCE/TRANSFORMFUNCTIONS
    ../EmbeddedModules/algorithm/cmsis_dsp/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.c arm_bitreversal_f16.c arm_cfft_f16.c arm_cfft_f32.c arm_cfft_f64.c arm_cfft_init_f16.c arm_cfft_init_f32.c arm_cfft_init_f64.c arm_cfft_init_q15.c arm_cfft_init_q31.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f16.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f16.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f16.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f16.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f16.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_mfcc_f16.c arm_mfcc_f32.c arm_mfcc_init_f16.c arm_mfcc_init_f32.c arm_mfcc_init_q15.c arm_mfcc_init_q31.c arm_mfcc_q15.c arm_mfcc_q31.c arm_rfft_f32.c arm_rfft_fast_f16.c arm_rfft_fast_f32.c arm_rfft_fast_f64.c arm_rfft_fast_init_f16.c arm_rfft_fast_init_f32.c arm_rfft_fast_init_f64.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c
  group ../EMBEDDEDMODULES/ALGORITHM/CMSIS_DSP/SOURCE/SVMFUNCTIONS
    ../EmbeddedModules/algorithm/cmsis_dsp/Source/SVMFunctions/: arm_svm_linear_init_f16.c arm_svm_linear_init_f32.c arm_svm_linear_predict_f16.c arm_svm_linear_predict_f32.c arm_svm_polynomial_init_f16.c arm_svm_polynomial_init_f32.c arm_svm_polynomial_predict_f16.c arm_svm_polynomial_predict_f32.c arm_svm_rbf_init_f16.c arm_svm_rbf_init_f32.c arm_svm_rbf_predict_f16.c arm_svm_rbf_predict_f32.c arm_svm_sigmoid_init_f16.c arm_svm_sigmoid_init_f32.c arm_svm_sigmoid_predict_f16.c arm_svm_sigmoid_predict_f32.c
  group ../EMBEDDEDMODULES/ALGORITHM/CMSIS_DSP/SOURCE/SUPPORTFUNCTIONS
    ../EmbeddedModules/algorithm/cmsis_dsp/Source/SupportFunctions/: arm_barycenter_f16.c arm_barycenter_f32.c arm_bitonic_sort_f32.c arm_bubble_sort_f32.c arm_copy_f16.c arm_copy_f32.c arm_copy_f64.c arm_copy_q15.c arm_copy_q31.c arm_copy_q7.c arm_f16_to_f64.c arm_f16_to_float.c arm_f16_to_q15.c arm_f64_to_f16.c arm_f64_to_float.c arm_f64_to_q15.c arm_f64_to_q31.c arm_f64_to_q7.c arm_fill_f16.c arm_fill_f32.c arm_fill_f64.c arm_fill_q15.c arm_fill_q31.c arm_fill_q7.c arm_float_to_f16.c arm_float_to_f64.c arm_float_to_q15.c arm_float_to_q31.c arm_float_to_q7.c arm_heap_sort_f32.c arm_insertion_sort_f32.c arm_merge_sort_f32.c arm_merge_sort_init_f32.c arm_q15_to_f16.c arm_q15_to_f64.c arm_q15_to_float.c arm_q15_to_q31.c arm_q15_to_q7.c arm_q31_to_f64.c arm_q31_to_float.c arm_q31_to_q15.c arm_q31_to_q7.c arm_q7_to_f64.c arm_q7_to_float.c arm_q7_to_q15.c arm_q7_to_q31.c arm_quick_sort_f32.c arm_selection_sort_f32.c arm_sort_f32.c arm_sort_init_f32.c arm_weighted_sum_f16.c arm_weighted_sum_f32.c
  group ../EMBEDDEDMODULES/ALGORITHM/CMSIS_DSP/SOURCE/STATISTICSFUNCTIONS
    ../EmbeddedModules/algorithm/cmsis_dsp/Source/StatisticsFunctions/: arm_absmax_f16.c arm_absmax_f32.c arm_absmax_f64.c arm_absmax_no_idx_f16.c arm_absmax_no_idx_f32.c arm_absmax_no_idx_f64.c arm_absmax_no_idx_q15.c arm_absmax_no_idx_q31.c arm_absmax_no_idx_q7.c arm_absmax_q15.c arm_absmax_q31.c arm_absmax_q7.c arm_absmin_f16.c arm_absmin_f32.c arm_absmin_f64.c arm_absmin_no_idx_f16.c arm_absmin_no_idx_f32.c arm_absmin_no_idx_f64.c arm_absmin_no_idx_q15.c arm_absmin_no_idx_q31.c arm_absmin_no_idx_q7.c arm_absmin_q15.c arm_absmin_q31.c arm_absmin_q7.c arm_accumulate_f16.c arm_accumulate_f32.c arm_accumulate_f64.c arm_entropy_f16.c arm_entropy_f32.c arm_entropy_f64.c arm_kullback_leibler_f16.c arm_kullback_leibler_f32.c arm_kullback_leibler_f64.c arm_logsumexp_dot_prod_f16.c arm_logsumexp_dot_prod_f32.c arm_logsumexp_f16.c arm_logsumexp_f32.c arm_max_f16.c arm_max_f32.c arm_max_f64.c arm_max_no_idx_f16.c arm_max_no_idx_f32.c arm_max_no_idx_f64.c arm_max_no_idx_q15.c arm_max_no_idx_q31.c arm_max_no_idx_q7.c arm_max_q15.c arm_max_q31.c arm_max_q7.c arm_mean_f16.c arm_mean_f32.c arm_mean_f64.c arm_mean_q15.c arm_mean_q31.c arm_mean_q7.c arm_min_f16.c arm_min_f32.c arm_min_f64.c arm_min_no_idx_f16.c arm_min_no_idx_f32.c arm_min_no_idx_f64.c arm_min_no_idx_q15.c arm_min_no_idx_q31.c arm_min_no_idx_q7.c arm_min_q15.c arm_min_q31.c arm_min_q7.c arm_mse_f16.c arm_mse_f32.c arm_mse_f64.c arm_mse_q15.c arm_mse_q31.c arm_mse_q7.c arm_power_f16.c arm_power_f32.c arm_power_f64.c arm_power_q15.c arm_power_q31.c arm_power_q7.c arm_rms_f16.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f16.c arm_std_f32.c arm_std_f64.c arm_std_q15.c arm_std_q31.c arm_var_f16.c arm_var_f32.c arm_var_f64.c arm_var_q15.c arm_var_q31.c
  group ../EMBEDDEDMODULES/ALGORITHM/CMSIS_DSP/SOURCE/QUATERNIONMATHFUNCTIONS
    ../EmbeddedModules/algorithm/cmsis_dsp/Source/QuaternionMathFunctions/: arm_quaternion2rotation_f32.c arm_quaternion_conjugate_f32.c arm_quaternion_inverse_f32.c arm_quaternion_normalize_f32.c arm_quaternion_norm_f32.c arm_quaternion_product_f32.c arm_quaternion_product_single_f32.c arm_rotation2quaternion_f32.c
  group ../EMBEDDEDMODULES/ALGORITHM/CMSIS_DSP/SOURCE/MATRIXFUNCTIONS
    ../EmbeddedModules/algorithm/cmsis_dsp/Source/MatrixFunctions/: arm_householder_f16.c arm_householder_f32.c arm_householder_f64.c arm_mat_add_f16.c arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cholesky_f16.c arm_mat_cholesky_f32.c arm_mat_cholesky_f64.c arm_mat_cmplx_mult_f16.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_cmplx_trans_f16.c arm_mat_cmplx_trans_f32.c arm_mat_cmplx_trans_q15.c arm_mat_cmplx_trans_q31.c arm_mat_init_f16.c arm_mat_init_f32.c arm_mat_init_f64.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f16.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_ldlt_f32.c arm_mat_ldlt_f64.c arm_mat_mult_f16.c arm_mat_mult_f32.c arm_mat_mult_f64.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_opt_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_mult_q7.c arm_mat_qr_f16.c arm_mat_qr_f32.c arm_mat_qr_f64.c arm_mat_scale_f16.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_solve_lower_triangular_f16.c arm_mat_solve_lower_triangular_f32.c arm_mat_solve_lower_triangular_f64.c arm_mat_solve_upper_triangular_f16.c arm_mat_solve_upper_triangular_f32.c arm_mat_solve_upper_triangular_f64.c arm_mat_sub_f16.c arm_mat_sub_f32.c arm_mat_sub_f64.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f16.c arm_mat_trans_f32.c arm_mat_trans_f64.c arm_mat_trans_q15.c arm_mat_trans_q31.c arm_mat_trans_q7.c arm_mat_vec_mult_f16.c arm_mat_vec_mult_f32.c arm_mat_vec_mult_q15.c arm_mat_vec_mult_q31.c arm_mat_vec_mult_q7.c
  group ../EMBEDDEDMODULES/ALGORITHM/CMSIS_DSP/SOURCE/INTERPOLATIONFUNCTIONS
    ../EmbeddedModules/algorithm/cmsis_dsp/Source/InterpolationFunctions/: arm_bilinear_interp_f16.c arm_bilinear_interp_f32.c arm_bilinear_interp_q15.c arm_bilinear_interp_q31.c arm_bilinear_interp_q7.c arm_linear_interp_f16.c arm_linear_interp_f32.c arm_linear_interp_q15.c arm_linear_interp_q31.c arm_linear_interp_q7.c arm_spline_interp_f32.c arm_spline_interp_init_f32.c
  group ../EMBEDDEDMODULES/ALGORITHM/CMSIS_DSP/SOURCE/FILTERINGFUNCTIONS
    ../EmbeddedModules/algorithm/cmsis_dsp/Source/FilteringFunctions/: arm_biquad_cascade_df1_32x64_init_q31.c arm_biquad_cascade_df1_32x64_q31.c arm_biquad_cascade_df1_f16.c arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_fast_q15.c arm_biquad_cascade_df1_fast_q31.c arm_biquad_cascade_df1_init_f16.c arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df1_init_q15.c arm_biquad_cascade_df1_init_q31.c arm_biquad_cascade_df1_q15.c arm_biquad_cascade_df1_q31.c arm_biquad_cascade_df2T_f16.c arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_f64.c arm_biquad_cascade_df2T_init_f16.c arm_biquad_cascade_df2T_init_f32.c arm_biquad_cascade_df2T_init_f64.c arm_biquad_cascade_stereo_df2T_f16.c arm_biquad_cascade_stereo_df2T_f32.c arm_biquad_cascade_stereo_df2T_init_f16.c arm_biquad_cascade_stereo_df2T_init_f32.c arm_conv_f32.c arm_conv_fast_opt_q15.c arm_conv_fast_q15.c arm_conv_fast_q31.c arm_conv_opt_q15.c arm_conv_opt_q7.c arm_conv_partial_f32.c arm_conv_partial_fast_opt_q15.c arm_conv_partial_fast_q15.c arm_conv_partial_fast_q31.c arm_conv_partial_opt_q15.c arm_conv_partial_opt_q7.c arm_conv_partial_q15.c arm_conv_partial_q31.c arm_conv_partial_q7.c arm_conv_q15.c arm_conv_q31.c arm_conv_q7.c arm_correlate_f16.c arm_correlate_f32.c arm_correlate_f64.c arm_correlate_fast_opt_q15.c arm_correlate_fast_q15.c arm_correlate_fast_q31.c arm_correlate_opt_q15.c arm_correlate_opt_q7.c arm_correlate_q15.c arm_correlate_q31.c arm_correlate_q7.c arm_fir_decimate_f32.c arm_fir_decimate_fast_q15.c arm_fir_decimate_fast_q31.c arm_fir_decimate_init_f32.c arm_fir_decimate_init_q15.c arm_fir_decimate_init_q31.c arm_fir_decimate_q15.c arm_fir_decimate_q31.c arm_fir_f16.c arm_fir_f32.c arm_fir_f64.c arm_fir_fast_q15.c arm_fir_fast_q31.c arm_fir_init_f16.c arm_fir_init_f32.c arm_fir_init_f64.c arm_fir_init_q15.c arm_fir_init_q31.c arm_fir_init_q7.c arm_fir_interpolate_f32.c arm_fir_interpolate_init_f32.c arm_fir_interpolate_init_q15.c arm_fir_interpolate_init_q31.c arm_fir_interpolate_q15.c arm_fir_interpolate_q31.c arm_fir_lattice_f32.c arm_fir_lattice_init_f32.c arm_fir_lattice_init_q15.c arm_fir_lattice_init_q31.c arm_fir_lattice_q15.c arm_fir_lattice_q31.c arm_fir_q15.c arm_fir_q31.c arm_fir_q7.c arm_fir_sparse_f32.c arm_fir_sparse_init_f32.c arm_fir_sparse_init_q15.c arm_fir_sparse_init_q31.c arm_fir_sparse_init_q7.c arm_fir_sparse_q15.c arm_fir_sparse_q31.c arm_fir_sparse_q7.c arm_iir_lattice_f32.c arm_iir_lattice_init_f32.c arm_iir_lattice_init_q15.c arm_iir_lattice_init_q31.c arm_iir_lattice_q15.c arm_iir_lattice_q31.c arm_levinson_durbin_f16.c arm_levinson_durbin_f32.c arm_levinson_durbin_q31.c arm_lms_f32.c arm_lms_init_f32.c arm_lms_init_q15.c arm_lms_init_q31.c arm_lms_norm_f32.c arm_lms_norm_init_f32.c arm_lms_norm_init_q15.c arm_lms_norm_init_q31.c arm_lms_norm_q15.c arm_lms_norm_q31.c arm_lms_q15.c arm_lms_q31.c
  group ../EMBEDDEDMODULES/ALGORITHM/CMSIS_DSP/SOURCE/FASTMATHFUNCTIONS
    ../EmbeddedModules/algorithm/cmsis_dsp/Source/FastMathFunctions/: arm_atan2_f16.c arm_atan2_f32.c arm_atan2_q15.c arm_atan2_q31.c arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_divide_q15.c arm_divide_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c arm_vexp_f16.c arm_vexp_f32.c arm_vexp_f64.c arm_vinverse_f16.c arm_vlog_f16.c arm_vlog_f32.c arm_vlog_f64.c arm_vlog_q15.c arm_vlog_q31.c
  group ../EMBEDDEDMODULES/ALGORITHM/CMSIS_DSP/SOURCE/DISTANCEFUNCTIONS
    ../EmbeddedModules/algorithm/cmsis_dsp/Source/DistanceFunctions/: arm_boolean_distance.c arm_braycurtis_distance_f16.c arm_braycurtis_distance_f32.c arm_canberra_distance_f16.c arm_canberra_distance_f32.c arm_chebyshev_distance_f16.c arm_chebyshev_distance_f32.c arm_chebyshev_distance_f64.c arm_cityblock_distance_f16.c arm_cityblock_distance_f32.c arm_cityblock_distance_f64.c arm_correlation_distance_f16.c arm_correlation_distance_f32.c arm_cosine_distance_f16.c arm_cosine_distance_f32.c arm_cosine_distance_f64.c arm_dice_distance.c arm_dtw_distance_f32.c arm_dtw_init_window_q7.c arm_dtw_path_f32.c arm_euclidean_distance_f16.c arm_euclidean_distance_f32.c arm_euclidean_distance_f64.c arm_hamming_distance.c arm_jaccard_distance.c arm_jensenshannon_distance_f16.c arm_jensenshannon_distance_f32.c arm_kulsinski_distance.c arm_minkowski_distance_f16.c arm_minkowski_distance_f32.c arm_rogerstanimoto_distance.c arm_russellrao_distance.c arm_sokalmichener_distance.c arm_sokalsneath_distance.c arm_yule_distance.c
  group ../EMBEDDEDMODULES/ALGORITHM/CMSIS_DSP/SOURCE/CONTROLLERFUNCTIONS
    ../EmbeddedModules/algorithm/cmsis_dsp/Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_init_q15.c arm_pid_init_q31.c arm_pid_reset_f32.c arm_pid_reset_q15.c arm_pid_reset_q31.c arm_sin_cos_f32.c arm_sin_cos_q31.c
  group ../EMBEDDEDMODULES/ALGORITHM/CMSIS_DSP/SOURCE/COMPLEXMATHFUNCTIONS
    ../EmbeddedModules/algorithm/cmsis_dsp/Source/ComplexMathFunctions/: arm_cmplx_conj_f16.c arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f16.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f16.c arm_cmplx_mag_f32.c arm_cmplx_mag_f64.c arm_cmplx_mag_fast_q15.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f16.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_f64.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f16.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_f64.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f16.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
  group ../EMBEDDEDMODULES/ALGORITHM/CMSIS_DSP/SOURCE/COMMONTABLES
    ../EmbeddedModules/algorithm/cmsis_dsp/Source/CommonTables/: arm_common_tables.c arm_common_tables_f16.c arm_const_structs.c arm_const_structs_f16.c arm_mve_tables.c arm_mve_tables_f16.c
  group ../EMBEDDEDMODULES/ALGORITHM/CMSIS_DSP/SOURCE/BAYESFUNCTIONS
    ../EmbeddedModules/algorithm/cmsis_dsp/Source/BayesFunctions/: arm_gaussian_naive_bayes_predict_f16.c arm_gaussian_naive_bayes_predict_f32.c
  group ../EMBEDDEDMODULES/ALGORITHM/CMSIS_DSP/SOURCE/BASICMATHFUNCTIONS
    ../EmbeddedModules/algorithm/cmsis_dsp/Source/BasicMathFunctions/: arm_abs_f16.c arm_abs_f32.c arm_abs_f64.c arm_abs_q15.c arm_abs_q31.c arm_abs_q7.c arm_add_f16.c arm_add_f32.c arm_add_f64.c arm_add_q15.c arm_add_q31.c arm_add_q7.c arm_and_u16.c arm_and_u32.c arm_and_u8.c arm_clip_f16.c arm_clip_f32.c arm_clip_q15.c arm_clip_q31.c arm_clip_q7.c arm_dot_prod_f16.c arm_dot_prod_f32.c arm_dot_prod_f64.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_dot_prod_q7.c arm_mult_f16.c arm_mult_f32.c arm_mult_f64.c arm_mult_q15.c arm_mult_q31.c arm_mult_q7.c arm_negate_f16.c arm_negate_f32.c arm_negate_f64.c arm_negate_q15.c arm_negate_q31.c arm_negate_q7.c arm_not_u16.c arm_not_u32.c arm_not_u8.c arm_offset_f16.c arm_offset_f32.c arm_offset_f64.c arm_offset_q15.c arm_offset_q31.c arm_offset_q7.c arm_or_u16.c arm_or_u32.c arm_or_u8.c arm_scale_f16.c arm_scale_f32.c arm_scale_f64.c arm_scale_q15.c arm_scale_q31.c arm_scale_q7.c arm_shift_q15.c arm_shift_q31.c arm_shift_q7.c arm_sub_f16.c arm_sub_f32.c arm_sub_f64.c arm_sub_q15.c arm_sub_q31.c arm_sub_q7.c arm_xor_u16.c arm_xor_u32.c arm_xor_u8.c
  group ../EMBEDDEDMODULES/ALGORITHM/CMSIS_DSP/COMPUTELIBRARY/SOURCE
    ../EmbeddedModules/algorithm/cmsis_dsp/ComputeLibrary/Source/: arm_cl_tables.c
